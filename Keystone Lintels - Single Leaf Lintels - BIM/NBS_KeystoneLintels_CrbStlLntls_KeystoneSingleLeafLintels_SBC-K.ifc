Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-11-12T09:32:20
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
COBie - Category: Levels; Name: Level 1

# IfcBeam: NBS_KeystoneLintels_CrbStlLntls_KeystoneSingleLeafLintels_SBC-K:SingleLeaf, NBS_KeystoneLintels_CrbStlLntls_KeystoneSingleLeafLintels_SBC-K:SingleLeaf:3600
In: Level 1
Type - PredefinedType: LINTEL
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_85_48_11:Carbon steel lintels; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Single Leaf Wall | BBA | Part L Compliant | UKCA | CE | Galvanized & Stainless; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Galvanized,Powder-coated; Grade: n/a; Manufacturer: info@keystonelintels.com; Material: Steel,Stainless steel; ModelNumber: SBC/K; ModelReference: Keystone Single Leaf Lintels; Name: CarbonSteelLintels_KeystoneSingleLeafLintels_SBC-K_KeystoneLintelsLtd; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_KeystoneLintelsLtd_CarbonSteelLintels_KeystoneSingleLeafLintels_SBC-K; ManufacturerName: Keystone Lintels Ltd; ManufacturerURL: www.keystonelintels.co.uk; ProductInformation: https://source.thenbs.com/product/-/11d6ae9d-4fc1-4d16-97a3-620bb9149c03/d0655ace-e3ca-4ea3-aa79-02bb055e15fc; Uniclass2015Title: Carbon steel lintels; Uniclass2015Code: Pr_20_85_48_11; Uniclass2015Version: Products v1.37; Version: 4
Type - NBS_Data - Accessories: Not required,Keying options to suit required plastering applications,Cant brick,Powder coating,Soffit cladding,Brick slip cladding,Universal arch,Weep holes,Stop ends,Bespoke; CharacteristicsResistanceToFire: Minimum period of 60 minutes, consult Keystone Lintels Technical Department; CharacteristicsThermalConductivity: Part L compliant; Duty: Standard duty,Heavy duty; LintelType: Composite; MaterialFinishAndCoatingReference: Pre-galvanized mild steel to BS EN 10346 DX51D with a zinc coating of 600 g/m² (including both sides). Material Coating Ref L14,Austenitic stainless steel, grade 304 2b BS EN 10088-Part 2 Astm 240 (European Grade 1.4307). Material Coating Ref L3,Austenitic stainless steel, grade 316 2b BS EN 10088-Part 2 Astm 316/316L (European Grade 1.4404). Material Coating Ref L1; Recyclability: 100% Recyclable; Sizes: As Lintels schedule; Standard: To BS EN 845-2
Type - IFC - IfcExportAs: IfcBeamType; IfcExportType: LINTEL
Material: NBS_KeystoneLintels_Steel
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
