Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-11-28T07:38:15
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
COBie - Category: Levels; Name: Level 1

# IfcBeam: NBS_KeystoneLintels_CrbStlLntls_IGCavityWallLintels_HD-K:CavityWidth-50–65mm, NBS_KeystoneLintels_CrbStlLntls_IGCavityWallLintels_HD-K:CavityWidth-50–65mm:3671
In: Level 1
Type - PredefinedType: LINTEL; Material: NBS_KeystoneLintels_Insulation, NBS_KeystoneLintels_Steel
Type - IFC - IfcExportAs: IfcBeamType; IfcExportType: LINTEL
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_85_48_11:Carbon steel lintels; Color: n/a; Finish: Galvanized,Powder-coated; Material: Steel,Stainless steel; Shape: n/a; Size: n/a; WarrantyDescription: n/a; CodePerformance: n/a; Constituents: n/a; Description: Cavity >50 mm | BBA | Part L Compliant | UKCA | CE | Galvanized & Stainless; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@keystonelintels.com; ModelNumber: HD/K-50; ModelReference: Keystone Cavity Wall Lintels; Name: CarbonSteelLintels_KeystoneCavityWallLintels_HD-K-50_CavityWidth-50–65mm_KeystoneLintelsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_KeystoneLintelsLtd_CarbonSteelLintels_KeystoneCavityWallLintels_HD-K-50_CavityWidth-50–65mm; ManufacturerName: Keystone Lintels Ltd; ManufacturerURL: www.keystonelintels.co.uk; ProductInformation: https://source.thenbs.com/product/-/a4ab8378-1c6d-4a0e-bcdc-1793dfd9ec43/59a9024c-c23d-49b8-bf0a-3bc0c60b932c; Uniclass2015Code: Pr_20_85_48_11; Uniclass2015Title: Carbon steel lintels; Uniclass2015Version: Products v1.37; Version: 6
Type - NBS_Data - Standard: To BS EN 845-2; LintelType: Composite; MaterialFinishAndCoatingReference: Pre-galvanized mild steel to BS EN 10346 DX51D with a zinc coating of 600 g/m² (including both sides). Material Coating Ref L14,Austenitic stainless steel, grade 304 2b BS EN 10088-Part 2 Astm 240 (European Grade 1.4307). Material Coating Ref L3,Austenitic stainless steel, grade 316 2b BS EN 10088-Part 2 Astm 316/316L (European Grade 1.4404). Material Coating Ref L1; Sizes: As Lintels schedule; CharacteristicsResistanceToFire: Has achieved a minimum period of 60 minutes in accordance with BS 476-20 and BS EN 1363-1; CharacteristicsThermalConductivity: Part L compliant; Recyclability: 100% Recyclable; CavityWidthOptions: 50–65 mm; Duty: Standard duty,Heavy duty,Extra heavy duty,Extreme duty; Accessories: Not required,Keying options to suit required plastering applications,Eaves lintel,Feature plate,Cant brick,Stepped,Powder coating,Soffit cladding,Brick slip cladding,Universal arch,Roller shutter,Weep holes,Stop ends,Bespoke
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
